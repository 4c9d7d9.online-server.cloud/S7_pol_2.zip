DATA_BLOCK DB 6
TITLE =
VERSION : 0.0

 FB 86
BEGIN
   TABLE := P#P  0.0;
   ERR_CODE := W#16#0;
   DIR := FALSE;
END_DATA_BLOCK

